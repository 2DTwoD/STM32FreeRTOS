# Keil uVision project freeRTOS.uvprojx, settings and files
target Root (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c include: .\Application\include;.\Tasks\include;.\FreeRTOS\include;.\FreeRTOS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/source/: init.c main.c register_work.c
  group Task
    ./Tasks/source/: led_task.c usart_task.c
  group FreeRTOS
    ./FreeRTOS/source/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/ARM_CM3/: port.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
